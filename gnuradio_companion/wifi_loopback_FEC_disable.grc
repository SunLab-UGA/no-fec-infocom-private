options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_loopback
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    start: '-20e-6'
    step: '1e-6'
    stop: '20e-6'
    value: '0'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '1000'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '64'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '-15'
    step: '0.1'
    stop: '30'
    value: '30'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '52'
  states: {state: disabled}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/wifi.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("p" for i in range(pdu_length)))
    period: interval
  states: {state: disabled}
- name: blocks_msgpair_to_var_0_0
  id: blocks_msgpair_to_var
  parameters:
    comment: |-
      the GUI will NOT update
      when the value is changed
    target: snr
  states: {}
- name: blocks_msgpair_to_var_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    comment: |-
      the GUI will NOT update
      when the value is changed
    target: epsilon
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    comment: |-
      the GUI will NOT update
      when the value is changed
    target: encoding
  states: {}
- name: blocks_msgpair_to_var_0_0_0_0_0
  id: blocks_msgpair_to_var
  parameters:
    comment: |-
      the GUI will NOT update
      when the value is changed
    target: noise
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: (10**(snr/10.0))**.5
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
    vlen: '52'
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: snr_changed
    target: snr
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: noise_changed
    target: noise
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: epsilon_changed
    target: epsilon
  states: {}
- name: blocks_var_to_msg_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: encoding_changed
    target: encoding
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '52'
    type: float
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: epsilon * 5.89e9 / 10e6
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"This block looks for a (key . value) pair to filter from a PMT message.\"\"\"\n\n    def __init__(self, key=\"\"):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name=\"PMT Filter\",   # will show up in GRC\n            in_sig=[],\n            out_sig=[]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.PMT_KEY = key\n\n        # message input port definition\n        self.in_mess = 'in'\n        self.message_port_register_in(pmt.intern(self.in_mess))\n        self.set_msg_handler(pmt.intern(self.in_mess), self.handler)\n\n        # message output port definition\n        self.out_mess = 'out'\n        self.message_port_register_out(pmt.intern(self.out_mess))\n\n    def work(self, input_items, output_items):\n        # output_items[0][:] = input_items[0] * self.example_param\n        # return len(output_items[0])\n        pass\n    \n    # def print_all_keys(pmt_dict, prefix=\"\"):\n    #     if pmt.is_dict(pmt_dict):\n    #         keys = pmt.dict_keys(pmt_dict)\n    #         for key in keys:\n    #             key_name = pmt.symbol_to_string(key)\n    #             full_key_name = prefix + key_name\n    #             print(f\"Key: {full_key_name}\")\n                \n    #             # Recursively call the function for nested dictionaries\n    #             sub_dict = pmt.dict_ref(pmt_dict, key)\n    #             if pmt.is_dict(sub_dict):\n    #                 # print_all_keys(sub_dict, prefix=full_key_name + \".\")\n    #                 pass\n\n    def handler(self, msg):\n        '''This is the handler for the message port'''\n        print(f\"PMT FILTER: Received message\")\n        # try to get the value from the message\n        value = pmt.pmt_to_python.pmt_to_python(msg)\n        # parse the message for the key\n        for v in value: # iterate through the message\n            # print(f\"value: {v}\")\n            for k in v:\n                # print(f\"key: {k}\")\n                if k == self.PMT_KEY:\n                    value = v[k]\n                    break\n            # if v == self.PMT_KEY:\n            # value = value[self.PMT_KEY]\n\n        # print(f\"Message: {value}\")\n        if value is not None:\n            # if the key exists, output it as a new message\n            # make new message\n            key = pmt.to_pmt(self.PMT_KEY)\n            value = pmt.to_pmt(value)\n            msg = pmt.cons(key, value)\n            # a = pmt.make_dict()\n            # a = pmt.dict_add(a, self.PMT_KEY, value)\n            self.message_port_pub(pmt.intern(self.out_mess), msg)\n        else:\n            print(f\"ERROR: Key {self.PMT_KEY} not found in message\")\n        \n\n"
    key: '''symbols'''
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"This block prints the full contents of a PMT message.\n    WARNING: This block may print a lot of data to the terminal, and may slow down GRC.\n    It's generally only used to debug the PMT messages\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name=\"PMT Finder\",   # will show up in GRC\n            in_sig=[],\n            out_sig=[]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        # self.print_values = print_values\n\n        # message input port definition\n        self.in_mess = 'in'\n        self.message_port_register_in(pmt.intern(self.in_mess))\n        self.set_msg_handler(pmt.intern(self.in_mess), self.handler)\n\n        # message output port definition\n        # self.out_mess = 'out'\n        # self.message_port_register_out(pmt.intern(self.out_mess))\n\n    def work(self, input_items, output_items):\n        # output_items[0][:] = input_items[0] * self.example_param\n        # return len(output_items[0])\n        pass\n    \n    # def print_all_keys(pmt_dict, prefix=\"\"):\n    #     if pmt.is_dict(pmt_dict):\n    #         keys = pmt.dict_keys(pmt_dict)\n    #         for key in keys:\n    #             key_name = pmt.symbol_to_string(key)\n    #             full_key_name = prefix + key_name\n    #             print(f\"Key: {full_key_name}\")\n                \n    #             # Recursively call the function for nested dictionaries\n    #             sub_dict = pmt.dict_ref(pmt_dict, key)\n    #             if pmt.is_dict(sub_dict):\n    #                 # print_all_keys(sub_dict, prefix=full_key_name + \".\")\n    #                 pass\n\n    def handler(self, msg):\n        '''This is the handler for the message port'''\n        print(f\"PMT FINDER: Received message\")\n        value = pmt.pmt_to_python.pmt_to_python(msg)\n        print(f\"Message: {value}\")\n        # print_all_keys(msg)\n        \n\n"
  states: {state: disabled}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'True'
    delay_sec: '0.001'
    minoutbuf: out_buf_size * 10
    pad_front: '500'
    pad_tail: '0'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_11_extract_csi_0
  id: ieee802_11_extract_csi
  parameters: {}
  states: {state: disabled}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    comment: |-
      BSS = Basic Service Set
      This is the AP ID ???
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1+epsilon
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,2
    size: 48*10
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '52'
    srate: '1'
    type: float
    ymax: '350'
  states: {state: disabled}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 10e6
    chan_est: ieee802_11.Equalizer(chan_est)
    encoding: ieee802_11.Encoding(encoding)
    frequency: 5.9e6
    sensitivity: '0.56'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:60002
    comment: TX_Data
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:60004
    comment: |-
      RX_Symbols (as symbols)
      RX_Data (as "")
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50000
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50001
    comment: freq offset
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50002
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50003
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0_0_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50010
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_message_strobe_0, strobe, ieee802_11_mac_0, app in]
- [blocks_multiply_const_xx_0, '0', channels_channel_model_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', pfb_arb_resampler_xxx_0, '0']
- [foo_packet_pad2_0, '0', blocks_multiply_const_xx_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_extract_csi_0, '0', blocks_complex_to_mag_0, '0']
- [ieee802_11_extract_csi_0, '0', blocks_tag_debug_0, '0']
- [ieee802_11_mac_0, phy out, epy_block_1_0, in]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [ieee802_11_mac_0, phy out, zeromq_pub_msg_sink_0, in]
- [ieee802_11_parse_mac_0, out, ieee802_11_extract_csi_0, pdu in]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, carrier, pdu_pdu_to_tagged_stream_0, pdus]
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]
- [wifi_phy_hier_0, mac_out, zeromq_pub_msg_sink_0_0, in]
- [zeromq_pull_msg_source_0, out, blocks_msgpair_to_var_0_0, inpair]
- [zeromq_pull_msg_source_0_0, out, blocks_msgpair_to_var_0_0_0, inpair]
- [zeromq_pull_msg_source_0_0_0, out, blocks_msgpair_to_var_0_0_0_0, inpair]
- [zeromq_pull_msg_source_0_0_0_0, out, blocks_msgpair_to_var_0_0_0_0_0, inpair]
- [zeromq_pull_msg_source_0_0_0_0_0, out, ieee802_11_mac_0, app in]

metadata:
  file_format: 1
